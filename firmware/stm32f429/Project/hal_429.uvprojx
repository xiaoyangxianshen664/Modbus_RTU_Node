# Keil uVision project hal_429.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hal_429
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --no-multibyte-chars
  c include: ..\Library\STM32F4xx_HAL_Driver\Inc;..\Library\CMSIS\Include;..\Library\CMSIS\Device\ST\STM32F4xx\Include;..\User;..\BSP;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\BSP\485;..\App;..\..\..\protocol\include;..\..\..\protocol\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Start
    ../Library/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group Library
    ../Library/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_sram.c stm32f4xx_hal_wwdg.c
  group CMISI
    ../Library/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Fatfs
    ../BSP/Fatfs/: diskio.c diskio.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h ffconf.h ffunicode.c sd_diskio.c sd_diskio.h
  group FreeRTOS/portable
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS/.c
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group BSP
    ../BSP/LED/: LED.c LED.h
    ../BSP/Key/: Key.c Key.h
    ../BSP/Exti/: Exti.c Exti.h
    ../BSP/Usart/: Usart.c Usart.h
    ../BSP/SysTick/: SysTick.c SysTick.h
    ../BSP/I2C/: I2C_EE.c I2C_EE.h
    ../BSP/TIM7/: TIM7.c TIM7.h
    ../BSP/TIM6/: TIM6.c TIM6.h
    ../BSP/485/: bsp_485.c bsp_485.h
    ../BSP/ADC/: ADC_Multi.c ADC_Multi.h
    ../BSP/SDIO/: bsp_sdio_sd.c bsp_sdio_sd.h
    ../BSP/IWDG/: iwdg.c iwdg.h
    ../BSP/RTC/: rtc.c rtc.h
  group User
    ../User/: main.c stm32f4xx_hal_conf.h stm32f4xx_it.c FreeRTOSConfig.h freertos_demo.c freertos_demo.h
  group protocol
    ../../../protocol/src/: modbus_crc16.c modbus_rtu.c modbus_registers.c
    ../../../protocol/include/: modbus_crc16.h modbus_rtu.h modbus_registers.h
  group App
    ../App/: modbus_transport.c modbus_transport.h
  group Test
    ../../../tests/: test_crc16.c test_modbus_protocol.c test_modbus_registers.c test_modbus_rtu.c
