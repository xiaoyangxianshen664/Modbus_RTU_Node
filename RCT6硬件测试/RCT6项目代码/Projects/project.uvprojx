# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\Dirvers\CMSIS\Include;..\Dirvers\STM32F1xx_HAL_Driver\Inc;..\Dirvers\CMSIS\Device\ST\STM32F1xx\Include;..\Users;..\Dirvers\SYSTEM;..\Dirvers\BSP;..\Middlewares\FatFs;..\App;..\Protocol;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../Dirvers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group Drivers/BSP
    ../Dirvers/BSP/: bsp.c gpio.c rct6_pinmap.h w25q256.c w25q256.h sd_card.c sd_card.h adc_multi.c adc_multi.h eeprom.c eeprom.h rs485.c rs485.h can_bus.c can_bus.h rtc_test.c rtc_test.h led.c led.h key.c key.h usart1.c usart1.h
  group Drivers/SYSTEM
    ../Dirvers/SYSTEM/: sys.c printf.c delay.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Dirvers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_i2c.c stm32f1xx_hal_can.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_spi.c stm32f1xx_hal_sd.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_iwdg.c
  group Middlewares/FatFs
    ../Middlewares/FatFs/: ff.c ff.h ffconf.h diskio.c diskio.h
  group Middlewares/FreeRTOS
    ../Middlewares/FreeRTOS/: tasks.c queue.c list.c
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
  group Protocol
    ../Protocol/: modbus_crc16.c modbus_registers.c modbus_rtu.c
  group Application
    ../App/: project_app.c modbus_transport.c config_storage.c iwdg.c
  group User
    ../Users/: main.c system_stm32f1xx.c stm32f1xx_it.c
